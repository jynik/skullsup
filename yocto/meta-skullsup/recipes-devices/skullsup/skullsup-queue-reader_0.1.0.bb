include skullsup.inc

# CA Certificates required for HTTPS client
RDEPENDS_${PN} += "ca-certificates"
